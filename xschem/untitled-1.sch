v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 2212.5 -882.5 2212.5 -22.5 {}
L 4 2232.5 -2.5 3122.5 -2.5 {}
L 4 3142.5 -882.5 3142.5 -22.5 {}
L 4 2232.5 -902.5 3122.5 -902.5 {}
T {DUT} 2247.5 -872.5 0 0 0.4 0.4 {}
N 980 -325 980 -305 {lab=vss}
N 980 -545 980 -525 {lab=vdd}
N 850 -545 850 -495 {lab=b0}
N 870 -545 870 -475 {lab=b1}
N 890 -545 890 -455 {lab=b2}
N 910 -545 910 -435 {lab=b3}
N 850 -355 850 -305 {lab=b7}
N 870 -375 870 -305 {lab=b6}
N 890 -395 890 -305 {lab=b5}
N 910 -415 910 -305 {lab=b4}
N 840 -495 920 -495 {lab=b0}
N 840 -475 920 -475 {lab=b1}
N 840 -455 920 -455 {lab=b2}
N 840 -435 920 -435 {lab=b3}
N 840 -415 920 -415 {lab=b4}
N 840 -395 920 -395 {lab=b5}
N 840 -375 920 -375 {lab=b6}
N 840 -355 920 -355 {lab=b7}
N 760 -325 760 -305 {lab=vss}
N 770 -545 770 -525 {lab=vdd}
N 750 -545 750 -525 {lab=vdd}
N 640 -425 670 -425 {lab=vdac}
N 790 -545 790 -525 {lab=clk_sample_b}
N 440 -330 440 -310 {lab=vdd}
N 440 -170 440 -150 {lab=vss}
N 350 -260 370 -260 {lab=clk}
N 510 -210 550 -210 {lab=clk_sample}
N 510 -230 550 -230 {lab=clk_sample_b}
N 510 -250 550 -250 {lab=clk_sar_b}
N 510 -270 550 -270 {lab=clk_sar}
N 350 -210 370 -210 {lab=reset_n}
N 1040 -425 1070 -425 {lab=clk_sample_b}
N 1040 -365 1070 -365 {lab=#net1}
N 1390 -365 1420 -365 {lab=Q}
N 465 -830 465 -810 {
lab=vss}
N 445 -830 445 -810 {
lab=clk_sample}
N 445 -910 445 -890 {
lab=clk_sample_b}
N 465 -910 465 -890 {
lab=vdd}
N 370 -860 400 -860 {
lab=VIN}
N 1170 -830 1200 -830 {
lab=clk_sar_b}
N 1300 -850 1340 -850 {
lab=Q}
N 1300 -810 1340 -810 {
lab=Q_B}
N 1250 -780 1250 -750 {
lab=vss}
N 1340 -810 1375 -810 {
lab=Q_B}
N 1340 -850 1375 -850 {
lab=Q}
N 1250 -910 1250 -880 {lab=vdd}
N 1260 -910 1260 -880 {lab=vb0}
N 520 -860 1200 -860 {lab=vsample}
N 640 -800 640 -425 {lab=vdac}
N 640 -800 1200 -800 {lab=vdac}
N 1040 -495 1070 -495 {lab=#net2}
N 1390 -495 1420 -495 {lab=clk}
N 880 -910 880 -860 {lab=vsample}
N 2497.5 -662.5 2497.5 -642.5 {
lab=vss}
N 2477.5 -662.5 2477.5 -642.5 {
lab=clk_sample}
N 2477.5 -742.5 2477.5 -722.5 {
lab=clk_sample_b}
N 2497.5 -742.5 2497.5 -722.5 {
lab=vdd}
N 2402.5 -692.5 2432.5 -692.5 {
lab=VIN}
N 2772.5 -662.5 2802.5 -662.5 {
lab=clk_sar_b}
N 2902.5 -682.5 2942.5 -682.5 {
lab=Q}
N 2902.5 -642.5 2942.5 -642.5 {
lab=Q_B}
N 2852.5 -612.5 2852.5 -582.5 {
lab=vss}
N 2942.5 -642.5 2977.5 -642.5 {
lab=Q_B}
N 2942.5 -682.5 2977.5 -682.5 {
lab=Q}
N 2672.5 -722.5 2672.5 -692.5 {lab=vsample}
N 2692.5 -632.5 2802.5 -632.5 {lab=vdac}
N 2552.5 -692.5 2802.5 -692.5 {lab=vsample}
N 2852.5 -742.5 2852.5 -712.5 {lab=vdd}
N 2742.5 -237.5 2742.5 -217.5 {lab=vss}
N 2742.5 -457.5 2742.5 -437.5 {lab=vdd}
N 2872.5 -457.5 2872.5 -407.5 {lab=b0}
N 2852.5 -457.5 2852.5 -387.5 {lab=b1}
N 2832.5 -457.5 2832.5 -367.5 {lab=b2}
N 2812.5 -457.5 2812.5 -347.5 {lab=b3}
N 2872.5 -267.5 2872.5 -217.5 {lab=b7}
N 2852.5 -287.5 2852.5 -217.5 {lab=b6}
N 2832.5 -307.5 2832.5 -217.5 {lab=b5}
N 2812.5 -327.5 2812.5 -217.5 {lab=b4}
N 2802.5 -407.5 2882.5 -407.5 {lab=b0}
N 2802.5 -387.5 2882.5 -387.5 {lab=b1}
N 2802.5 -367.5 2882.5 -367.5 {lab=b2}
N 2802.5 -347.5 2882.5 -347.5 {lab=b3}
N 2802.5 -327.5 2882.5 -327.5 {lab=b4}
N 2802.5 -307.5 2882.5 -307.5 {lab=b5}
N 2802.5 -287.5 2882.5 -287.5 {lab=b6}
N 2802.5 -267.5 2882.5 -267.5 {lab=b7}
N 2962.5 -237.5 2962.5 -217.5 {lab=vss}
N 2952.5 -457.5 2952.5 -437.5 {lab=vdd}
N 2972.5 -457.5 2972.5 -437.5 {lab=vdd}
N 3052.5 -337.5 3082.5 -337.5 {lab=vdac}
N 2932.5 -457.5 2932.5 -437.5 {lab=clk_sample_b}
N 2422.5 -257.5 2422.5 -237.5 {lab=vdd}
N 2422.5 -97.5 2422.5 -77.5 {lab=vss}
N 2332.5 -187.5 2352.5 -187.5 {lab=clk}
N 2492.5 -137.5 2532.5 -137.5 {lab=clk_sample}
N 2492.5 -157.5 2532.5 -157.5 {lab=clk_sample_b}
N 2492.5 -177.5 2532.5 -177.5 {lab=clk_sar_b}
N 2492.5 -197.5 2532.5 -197.5 {lab=clk_sar}
N 2332.5 -137.5 2352.5 -137.5 {lab=reset_n}
N 2652.5 -337.5 2682.5 -337.5 {lab=clk_sample_b}
N 2652.5 -277.5 2682.5 -277.5 {lab=#net1}
N 2862.5 -742.5 2862.5 -712.5 {lab=vb0}
C {lab_pin.sym} 980 -305 1 1 {name=p24 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 980 -545 1 0 {name=p15 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 850 -545 1 0 {name=p16 sig_type=std_logic lab=b0
}
C {lab_pin.sym} 870 -545 1 0 {name=p17 sig_type=std_logic lab=b1
}
C {lab_pin.sym} 890 -545 1 0 {name=p19 sig_type=std_logic lab=b2
}
C {lab_pin.sym} 910 -545 1 0 {name=p22 sig_type=std_logic lab=b3
}
C {lab_pin.sym} 910 -305 3 0 {name=p25 sig_type=std_logic lab=b4
}
C {lab_pin.sym} 890 -305 3 0 {name=p27 sig_type=std_logic lab=b5
}
C {lab_pin.sym} 870 -305 3 0 {name=p28 sig_type=std_logic lab=b6
}
C {lab_pin.sym} 850 -305 3 0 {name=p30 sig_type=std_logic lab=b7
}
C {lab_pin.sym} 640 -800 2 1 {name=p33 sig_type=std_logic lab=vdac
}
C {lab_pin.sym} 760 -305 1 1 {name=p34 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 770 -545 1 0 {name=p36 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 750 -545 1 0 {name=p39 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 790 -545 1 0 {name=p44 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 350 -260 0 0 {name=p45 sig_type=std_logic lab=clk
}
C {lab_pin.sym} 440 -150 0 0 {name=p46 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 440 -330 0 0 {name=p47 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 550 -270 0 1 {name=p48 sig_type=std_logic lab=clk_sar
}
C {lab_pin.sym} 550 -250 0 1 {name=p49 sig_type=std_logic lab=clk_sar_b
}
C {lab_pin.sym} 550 -230 0 1 {name=p53 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 550 -210 0 1 {name=p54 sig_type=std_logic lab=clk_sample
}
C {lab_pin.sym} 350 -210 0 0 {name=p1 sig_type=std_logic lab=reset_n
}
C {lab_pin.sym} 1070 -425 2 0 {name=p65 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 1420 -365 0 1 {name=p72 sig_type=std_logic lab=Q}
C {lab_pin.sym} 1420 -495 0 1 {name=p29 sig_type=std_logic lab=clk
}
C {sky130_stdcells/inv_1.sym} 1350 -365 0 1 {name=x28 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 1350 -495 0 1 {name=x36 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} 1270 -365 0 1 {name=x38 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} 1270 -495 0 1 {name=x33 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} 1190 -495 0 1 {name=x34 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 1110 -495 0 1 {name=x37 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sar_logic/sarlogic.sym} 1230 -235 0 1 {name=X5}
C {dac/dac.sym} 880 -305 0 1 {name=X6}
C {clockgen/clockgen.sym} 330 -150 0 0 {name=X3}
C {lab_pin.sym} 370 -860 2 1 {name=p6 sig_type=std_logic lab=VIN
}
C {lab_pin.sym} 880 -910 3 1 {name=p7 sig_type=std_logic lab=vsample
}
C {lab_pin.sym} 1250 -910 1 0 {name=p10 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 1375 -850 2 0 {name=p8 sig_type=std_logic lab=Q
}
C {lab_pin.sym} 1375 -810 2 0 {name=p14 sig_type=std_logic lab=Q_B
}
C {lab_pin.sym} 445 -810 1 1 {name=p5 sig_type=std_logic lab=clk_sample}
C {lab_pin.sym} 1170 -830 2 1 {name=p9 sig_type=std_logic lab=clk_sar_b
}
C {lab_pin.sym} 465 -910 2 0 {name=p2 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 465 -810 0 1 {name=p3 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 1250 -750 1 1 {name=p13 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 445 -910 3 1 {name=p4 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 1260 -910 2 0 {name=p31 sig_type=std_logic lab=vb0
}
C {comparator/comparator.sym} 1250 -830 0 0 {name=X2}
C {sample/sample_hold.sym} 460 -860 0 0 {name=X1}
C {sky130_stdcells/inv_8.sym} 1190 -365 0 1 {name=x4 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 1110 -365 0 1 {name=x7 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 640 -425 2 1 {name=p11 sig_type=std_logic lab=vdac
}
C {lab_pin.sym} 2402.5 -692.5 2 1 {name=p12 sig_type=std_logic lab=VIN
}
C {lab_pin.sym} 2672.5 -722.5 3 1 {name=p18 sig_type=std_logic lab=vsample
}
C {lab_pin.sym} 2852.5 -742.5 1 0 {name=p20 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 2977.5 -682.5 2 0 {name=p21 sig_type=std_logic lab=Q
}
C {lab_pin.sym} 2977.5 -642.5 2 0 {name=p23 sig_type=std_logic lab=Q_B
}
C {lab_pin.sym} 2477.5 -642.5 1 1 {name=p26 sig_type=std_logic lab=clk_sample}
C {lab_pin.sym} 2772.5 -662.5 2 1 {name=p32 sig_type=std_logic lab=clk_sar_b
}
C {lab_pin.sym} 2497.5 -742.5 2 0 {name=p35 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 2497.5 -642.5 0 1 {name=p37 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 2852.5 -582.5 1 1 {name=p38 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 2742.5 -217.5 3 0 {name=p40 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 2742.5 -457.5 3 1 {name=p41 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 2872.5 -457.5 3 1 {name=p42 sig_type=std_logic lab=b0
}
C {lab_pin.sym} 2852.5 -457.5 3 1 {name=p43 sig_type=std_logic lab=b1
}
C {lab_pin.sym} 2832.5 -457.5 3 1 {name=p50 sig_type=std_logic lab=b2
}
C {lab_pin.sym} 2812.5 -457.5 3 1 {name=p51 sig_type=std_logic lab=b3
}
C {lab_pin.sym} 2812.5 -217.5 1 1 {name=p52 sig_type=std_logic lab=b4
}
C {lab_pin.sym} 2832.5 -217.5 1 1 {name=p55 sig_type=std_logic lab=b5
}
C {lab_pin.sym} 2852.5 -217.5 1 1 {name=p56 sig_type=std_logic lab=b6
}
C {lab_pin.sym} 2872.5 -217.5 1 1 {name=p57 sig_type=std_logic lab=b7
}
C {lab_pin.sym} 3082.5 -337.5 2 0 {name=p58 sig_type=std_logic lab=vdac
}
C {lab_pin.sym} 2962.5 -217.5 3 0 {name=p59 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 2952.5 -457.5 3 1 {name=p60 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 2972.5 -457.5 3 1 {name=p61 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 2932.5 -457.5 3 1 {name=p62 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 2332.5 -187.5 0 0 {name=p63 sig_type=std_logic lab=clk
}
C {lab_pin.sym} 2422.5 -77.5 0 0 {name=p64 sig_type=std_logic lab=vss
}
C {lab_pin.sym} 2422.5 -257.5 0 0 {name=p66 sig_type=std_logic lab=vdd
}
C {lab_pin.sym} 2532.5 -197.5 0 1 {name=p67 sig_type=std_logic lab=clk_sar
}
C {lab_pin.sym} 2532.5 -177.5 0 1 {name=p68 sig_type=std_logic lab=clk_sar_b
}
C {lab_pin.sym} 2532.5 -157.5 0 1 {name=p69 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 2532.5 -137.5 0 1 {name=p70 sig_type=std_logic lab=clk_sample
}
C {lab_pin.sym} 2692.5 -632.5 0 0 {name=p71 sig_type=std_logic lab=vdac
}
C {lab_pin.sym} 2332.5 -137.5 0 0 {name=p73 sig_type=std_logic lab=reset_n
}
C {lab_pin.sym} 2477.5 -742.5 3 1 {name=p74 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 2652.5 -337.5 2 1 {name=p75 sig_type=std_logic lab=clk_sample_b
}
C {lab_pin.sym} 2492.5 -277.5 0 0 {name=p76 sig_type=std_logic lab=Q}
C {lab_pin.sym} 2362.5 -407.5 0 0 {name=p77 sig_type=std_logic lab=clk
}
C {sky130_stdcells/inv_1.sym} 2532.5 -277.5 0 0 {name=x8 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_1.sym} 2402.5 -407.5 0 0 {name=x9 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} 2612.5 -277.5 0 0 {name=x10 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_4.sym} 2482.5 -407.5 0 0 {name=x11 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_8.sym} 2562.5 -407.5 0 0 {name=x12 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {sky130_stdcells/inv_16.sym} 2642.5 -407.5 0 0 {name=x13 VGND=vss VNB=vss VPB=vdd VPWR=vdd prefix=sky130_fd_sc_hd__ }
C {lab_pin.sym} 2862.5 -742.5 2 0 {name=p78 sig_type=std_logic lab=vb0
}
C {comparator/comparator.sym} 2852.5 -662.5 0 0 {name=X14}
C {sar_logic/sarlogic.sym} 2492.5 -147.5 0 0 {name=X15}
C {dac/dac.sym} 2842.5 -217.5 0 0 {name=X16}
C {clockgen/clockgen.sym} 2312.5 -77.5 0 0 {name=X17}
C {sample/sample_hold.sym} 2492.5 -692.5 0 0 {name=X18}
