v {xschem version=3.4.6RC file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
L 4 -60 -20 -30 -20 {}
L 4 -60 20 -30 20 {}
L 4 -30 -40 -30 40 {}
L 4 10 -20 40 -20 {}
L 4 10 20 40 20 {}
L 4 -30 -40 50 0 {}
L 4 -30 40 50 0 {}
L 4 -10 -50 -10 -30 {}
L 4 -10 30 -10 50 {}
